# IAR project MyAPP.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F469NI ST STM32F469NI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F469xx
  ICCARM.CCIncludePath2: Application\Src; Application\Inc; Drivers\BSP; Drivers\CMSIS; Drivers\DSP_Lib; Drivers\Startup; Drivers\STM32F4xx_HAL_Driver\Inc; Drivers\STM32F4xx_HAL_Driver\Src; FatFs; STemWin\Config; μcosii\Source; μcosii\Cfg; μcosii\Ports; FatFs; SysFun; STemWin\inc; STemWin\OS; STemWin\PNGLib
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MyAPP.hex
  ILINK.IlinkOutputFile: MyAPP.out
  ILINK.IlinkIcfFile: E:\prj\ARM\STM32F469\MyApp\MyAPP.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  group Application
    Application/Src/: app_hooks.c main.c stm32f4xx_hal_msp.c stm32f4xx_it.c
  group Doc
    Doc/: readme.txt
  group Drivers/BSP
    Drivers/BSP/: bsp.c bsp_lcd.c bsp_sd.c bsp_sdram.c bsp_ts.c ft6x06.c otm8009a.c
  group Drivers/CMSIS
    Drivers/CMSIS/: system_stm32f4xx.c
  group Drivers/DSP_Lib
    Drivers/DSP_Lib/: libarm_cortexM4lf_math.a
  group Drivers/Startup
    Drivers/Startup/: startup_stm32f469xx.s
  group Drivers/STM32F4xx_HAL_Driver
    Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dsi.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_lptim.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_spdifrx.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_usb.c
  group FatFs
    FatFs/: diskio.c ff.c
  group STemWin/Config
    STemWin/Config/: GUIConf.c LCDConf.c
  group STemWin/Lib
    STemWin/Lib/: STemWin528_CM4_IAR.a
  group STemWin/OS
    STemWin/OS/: GUI_X.c
  group STemWin/PNGLib
    STemWin/PNGLib/: adler32.c compress.c crc32.c deflate.c GUI_PNG.c gzio.c IMAGE_PNG.c infback.c inffast.c inflate.c inftrees.c png.c pngerror.c pnggccrd.c pngget.c pngmem.c pngpread.c pngread.c pngrio.c pngrtran.c pngrutil.c pngset.c pngtrans.c pngvcrd.c pngwio.c pngwrite.c pngwtran.c pngwutil.c trees.c uncompr.c zutil.c
  group SysFun
    SysFun/: displaybmp.c displaygif.c displayjpeg.c displaypng.c malloc.c
  group μcosii/Cfg
    μcosii/Cfg/: os_cfg.h
  group μcosii/Port
    μcosii/Ports/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group μcosii/Source
    μcosii/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
